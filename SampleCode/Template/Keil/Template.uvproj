# Keil uVision project Template.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: template +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\Library\StdDriver\inc;..\..\Template;..\TFT_ILI9341;..\TFT_ILI9341\Fonts;..\TFT_ILI9341\examples
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  memory RVCT10: RAM 0x20003ffc size 0x4
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c timer.c uart.c fmc.c adc.c
  group User
    ../: main.c gpio_EBI.c
  group TFT_ILI9341
    ../TFT_ILI9341/: TFT_ILI9341.c
  group TFT_ILI9341_Fonts
    ../TFT_ILI9341/Fonts/: Font7srle.c Font16.c Font32rle.c Font64rle.c Font72rle.c glcdfont.c
  group TFT_ILI9341_examples
    ../TFT_ILI9341/examples/: RLE_Font_test.c TFT_ArcFill.c TFT_ArcFill_2.c TFT_Char_times.c TFT_Clock.c TFT_Clock_Digital.c TFT_Clock_Digital2.c TFT_Ellipse.c TFT_FillArcSpiral.c TFT_Flash_Bitmap.c TFT_Float_Test.c TFT_graphicstest_one_lib.c TFT_graphicstest_PDQ.c TFT_Mandlebrot.c TFT_Matrix_2.c TFT_Meter_linear_4.c TFT_Meters.c TFT_Pie_Chart.c TFT_Pong_v2.c TFT_Print_Test.c TFT_Rainbow_one_lib.c TFT_Spiro_2.c TFT_Starfield.c TFT_String_Align.c TFT_Terminal.c UTFT_demo_fast_2.c
